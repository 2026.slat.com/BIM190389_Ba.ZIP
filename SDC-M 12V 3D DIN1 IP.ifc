Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-07-30T13:13:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 30 13:13:41 2019 * Host: Piranha * Database: C:\Users\datBIM\AppData\Local\Temp\{A867AE33-7797-4FCE-9CAE-AA8AAA600016}\ifc * Database version: 5507 * Database creation date: Tue Jul 30 13:13:38 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 30 13:13:39 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 30 13:13:39 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm

# IfcBuildingElementProxy: SDC-M 12V 3D DIN1 IP, SDC-M 12V 3D DIN1 IP:SDC-M 12V 3D DIN1 IP:137601
In: Niveau 1
Pset_ManufacturerTypeInformation - Manufacturer: SLAT
Pset_BuildingElementProxyCommon - Reference: SDC-M 12V 3D DIN1 IP
